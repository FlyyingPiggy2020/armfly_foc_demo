# Keil uVision project mdk.uvprojx, settings and files
target mdk (6240000::V6.24::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: armfly-v7 +hex
  BeforeMake: python ..\..\..\fbtools.py before
  AfterMake: python ..\..\..\fbtools.py after
  AfterMake: keil-build-viewer.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,FP_INCLDUE_BOARD_OPTIONS_FILE,FOC_OPTIONS_FILE,CONFIG_HEAP_TYPE=1,FOC_INCLDUE_BOARD_OPTIONS_FILE
  c misc: -std=c11
  c include: ..\..\..\app;..\src;..\cpu\inc;..\config;..\bsp;..\..\..\components\fp-sdk\inc;..\..\..\components\fp-sdk\drivers\core;..\..\..\components\fp-sdk\drivers\device\bus;..\..\..\components\fp-sdk\drivers\device;..\..\..\components\fp-sdk\drivers\device\input;..\..\..\components\fp-sdk\drivers\device\storage;..\..\..\components\fp-sdk\drivers\device\sensor;..\..\..\components\fp-sdk\packages;..\..\..\components\fp-sdk\utilities;..\..\..\components\fp-sdk\utilities\message_bus;..\..\..\components\fp-sdk\motion\foc;..\..\..\components\fp-sdk\motion\foc\math;..\..\..\components\fp-sdk\motion\foc\control\pi;..\..\..\lib\STMicroelectronics\stm32h7xx\arch\inc;..\..\..\lib\STMicroelectronics\stm32h7xx\peripheral\inc;..\..\..\lib\STMicroelectronics\stm32h7xx\peripheral\inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\config\arm\debug.sct
  group app
    ../../../app/: app_comm.c app_foc.c app_key.c
  group app_msgbus
    ../../../app/: logic_key.c logic_debug.c app_msgbus.c
  group bsp
    ../bsp/: bsp_foc.c bsp_adc.c bsp_pwm.c bsp_key.c bsp_uart.c bsp_spi.c bsp_encoder.c
  group board/src
    ../src/: main.c
  group board/cpu
    ../cpu/: cpu.c stm32h7xx_it.c
    ../cpu/arm/: startup_stm32h743xx.s
  group board/config
    ../config/: board_options.h flash_map.h stm32h7xx_hal_conf.h
    ../config/arm/: debug.sct
  group lib/arch
    ../../../lib/STMicroelectronics/stm32h7xx/arch/: system_stm32h7xx.c
  group lib/peripheral
    ../../../lib/STMicroelectronics/stm32h7xx/peripheral/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group fp-sdk/core
    ../../../components/fp-sdk/drivers/core/: device.c driver.c
  group fp-sdk/device
    ../../../components/fp-sdk/drivers/device/: analog.c pwmc.c dev_uart.c
    ../../../components/fp-sdk/drivers/device/input/: button.c
    ../../../components/fp-sdk/drivers/device/bus/: spi_bus.c
  group fp-sdk/motion/foc
    ../../../components/fp-sdk/motion/foc/: foc.c
    ../../../components/fp-sdk/motion/foc/math/: foc_math.c
    ../../../components/fp-sdk/motion/foc/control/pi/: foc_pi.c
  group fp-sdk/utilities
    ../../../components/fp-sdk/utilities/: heap.c fplog.c pingpong.c soft_timer.c
    ../../../components/fp-sdk/utilities/butter/: butter.c
    ../../../components/fp-sdk/utilities/message_bus/: message_bus.c
    ../../../components/fp-sdk/packages/vofa/: vofa.c
    ../../../components/fp-sdk/packages/tle5012b/: tle5012b_sensor.c
